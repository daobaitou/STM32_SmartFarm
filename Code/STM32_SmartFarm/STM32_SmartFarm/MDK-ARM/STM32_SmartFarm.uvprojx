# Keil uVision project STM32_SmartFarm.uvprojx, settings and files
target STM32_SmartFarm (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_SmartFarm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App/Sensors;../App/Utils;..\App\Display;..\App\Drivers;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\portable\ARM_CM3;..\Core\Inc;..\App\Tasks;..\App\Storage;..\App\Communication;..\App\Control;..\App\Alarm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../App/Utils/: retarget.c
    ../App/Sensors/: sensor_dht22.c sensor_dht22.h sensor_ds18b20.c sensor_fc28.c sensor_bh1750.c sensor_bmp180.c sensor_yfs201.c sensor_mhz19b.c
    ../Core/Src/: main.c gpio.c adc.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../App/Display/: display_oled.c
    ../App/Drivers/: soft_i2c.c soft_spi.c
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim_ex.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Source
    ../Middlewares/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../Middlewares/FreeRTOS/Source/portable/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/Source/portable/: heap_4.c
  group APP/Tasks
    ../App/Tasks/: app_tasks.c
  group APP/Storage
    ../App/Storage/: w25q_flash.c storage_manager.c
  group APP/Communication
    ../App/Communication/: usart2_driver.c uart_bridge.c
  group App/Control
    ../App/Control/: pump_control.c servo_control.c fan_control.c
  group App/Alarm
    ../App/Alarm/: alarm_driver.c
  group Core/Src
    ../Core/Src/: tim.c
software components: CMSIS:CORE 4.3.0
